# IAR project stm32_iic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; CONFIG_SI7020
  ICCARM.CCIncludePath2: ..\..\com\cmsis; ..\..\com\rtt; user; ..\bsp\ip_driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_iic.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../bsp/startup/: startup_stm32f10x_md.s
  group rtt
    ../../com/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group stm32
    ../bsp/ip_driver/: stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c system_stm32f10x.c
  group user
    user/: atmlh751.c iic.c main.c si7021.c
