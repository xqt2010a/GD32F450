# IAR project stm32_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\com\cmsis; ..\..\com\rtt; ..\..\com\freertos\include; ..\..\com\freertos\portable\IAR\ARM_CM3; user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: user
  OBJCOPY.OOCOutputFile: stm32_freertos.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../bsp/startup/: startup_stm32f10x_md.s
  group freertos
    ../../com/freertos/portable/MemMang/: heap_3.c
    ../../com/freertos/: list.c queue.c tasks.c
    ../../com/freertos/portable/IAR/ARM_CM3/: port.c portasm.s
  group rtt
    ../../com/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group stm32
    ../bsp/ip_driver/: system_stm32f10x.c
  group user
    user/: main.c
