# IAR project stm32_los.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCIncludePath2: ..\..\com\cmsis; ..\..\com\rtt; los
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_los.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../bsp/startup/: startup_stm32f10x_md.s
  group los
    los/: los.c los_arch.c los_task.c
  group rtt
    ../../com/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group stm32
    ../bsp/ip_driver/: system_stm32f10x.c
  group user
    user/: main.c
