# IAR project stm32_USB_VirUart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ; Libraries\FWLib\inc; Libraries\CMSIS; STM32_USB-FS-Device_Driver; USB\include; User; User\led; User\usart; RTT
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_USB_VirUart.hex
  ILINK.IlinkOutputFile: stm32_USB_VirUart.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: startup_stm32f10x_md.s
  group fwlib
    Libraries/FWLib/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_usart.c
  group rtt
    RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group stm32_usb_driver
    STM32_USB-FS-Device_Driver/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group usb&usart
    USB/source/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group user
    User/led/: bsp_led.c
    User/usart/: bsp_usart1.c
    User/: main.c stm32f10x_it.c
