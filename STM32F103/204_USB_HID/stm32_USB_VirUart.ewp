# IAR project stm32_USB_VirUart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: RTT; STM32_USB-FS-Device_Driver\inc; STM32F10x_StdPeriph_Driver\inc; User_USB; STM32F10x_StdPeriph_Driver; User
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_USB_VirUart.hex
  ILINK.IlinkOutputFile: stm32_USB_VirUart.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: startup_stm32f10x_md.s
  group RTT
    RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group STM32_USB
    STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c
  group user
    User/: hw_config.c led.c main.c stm3210e_eval.c stm32_it.c system_stm32f10x.c user_hid.c
  group USER_USB
    User_USB/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
