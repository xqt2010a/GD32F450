# IAR project CMSIS_DAP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: DAP; CMSIS; USB; Device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CMSIS_DAP.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkAdditionalLibs: CMSIS\RTX_CM3.a; USB\USB_CM3_L.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/: OTG_STM32F10x_cl.c RTX_Conf_CM.c USBD_STM32F10x.c
  group DAP
    DAP/: DAP.c JTAG_DP.c SW_DP.c SWO.c
  group USB
    USB/: USBD_Config_0.c
