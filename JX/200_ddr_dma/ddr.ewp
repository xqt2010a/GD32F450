# IAR project ddr.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: user; ..\bsp\ip; ..\..\com\rtt
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ddr.bin
  ILINK.IlinkOutputFile: uart.out
  ILINK.IlinkIcfFile: jx_iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../bsp/startup/: start.s
  group jx
    ../bsp/ip/: system.c
  group user
    user/: ddr_test.c dv_ddr_code.c lpddr4_init.c main.c phy_init.c uart.c
