# IAR project dma.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: user; ..\bsp\ip; ..\..\com\ipr
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dma.bin
  ILINK.IlinkOutputFile: uart.out
  ILINK.IlinkIcfFile: jx_iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../bsp/startup/: startup_jx.s
  group jx
    ../../com/ipr/: dwc_dma.c
    ../bsp/ip/: jx_dma.c jx_uart.c system.c
  group user
    user/: main.c
